# Keil uVision project MyProject.uvprojx, settings and files
target Release (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.1
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MyProject +hex
  AfterMake: fromelf.exe --bin "STEVAL-IDB007V1M\Release\Objects\@H.axf" --output "STEVAL-IDB007V1M\Release\@H.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: SMPS_INDUCTOR=SMPS_INDUCTOR_10uH LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ USE_FULL_ASSERT BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_2
  c misc: --wchar32
  c include: ..\src;..\BlueNRG-1_2 DK 3.2.3\Library\BLE_Application\layers_inc;..\BlueNRG-1_2 DK 3.2.3\Library\BLE_Application\OTA\inc;..\BlueNRG-1_2 DK 3.2.3\Library\BLE_Application\Utils\inc;..\BlueNRG-1_2 DK 3.2.3\Library\BlueNRG1_Periph_Driver\inc;..\BlueNRG-1_2 DK 3.2.3\Library\Bluetooth_LE\inc;..\BlueNRG-1_2 DK 3.2.3\Library\CMSIS\Device\ST\BlueNRG1\Include;..\BlueNRG-1_2 DK 3.2.3\Library\CMSIS\Include;..\BlueNRG-1_2 DK 3.2.3\Library\FreeRTOS\BlueNRG;..\BlueNRG-1_2 DK 3.2.3\Library\FreeRTOS\Source\include;..\BlueNRG-1_2 DK 3.2.3\Library\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\BlueNRG-1_2 DK 3.2.3\Library\hal\inc;..\BlueNRG-1_2 DK 3.2.3\Library\SDK_Eval_BlueNRG1\inc
  asm misc: --cpreproc --cpreproc_opts=-DCONTEXT_SAVE_V2
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\STEVAL-IDB007V1M\BlueNRG1.sct
  group BlueNRG-1_2 DK 3.2.3
    ../BlueNRG-1_2 DK 3.2.3/Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_timer.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
    ../BlueNRG-1_2 DK 3.2.3/Library/CMSIS/Device/ST/BlueNRG1/Source/: system_BlueNRG1.c
    ../BlueNRG-1_2 DK 3.2.3/Library/hal/src/: context_switch.s miscutil.c sleep.c osal.c
    ../BlueNRG-1_2 DK 3.2.3/Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
    ../BlueNRG-1_2 DK 3.2.3/Library/BLE_Application/Utils/src/: ble_utils.c
    ../BlueNRG-1_2 DK 3.2.3/Library/Bluetooth_LE/src/: stack_user_cfg.c
    ../BlueNRG-1_2 DK 3.2.3/Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../BlueNRG-1_2 DK 3.2.3/Library/cryptolib/: libcrypto.a
  group FreeRTOS
    ../BlueNRG-1_2 DK 3.2.3/Library/FreeRTOS/Source/: queue.c tasks.c list.c timers.c
    ../BlueNRG-1_2 DK 3.2.3/Library/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../BlueNRG-1_2 DK 3.2.3/Library/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../BlueNRG-1_2 DK 3.2.3/Library/FreeRTOS/BlueNRG/: freertos_lp.c
  group User
    ../src/: BlueNRG1_it.c main.c
